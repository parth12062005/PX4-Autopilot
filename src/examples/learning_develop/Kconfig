## src/examples/learning_develop/Kconfig
```kconfig
menuconfig EXAMPLES_LEARNING_DEVELOP
    bool "learning_develop"
    default n
    ---help---
        Enable support for learning_develop
```
